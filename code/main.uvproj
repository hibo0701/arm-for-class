# Keil uVision project main.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2138 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: main +hex
  c flags: Optim=1
  c include: .\src;.\user
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  scatter file: .\src\MEM_C.SCF
  link misc: --entry Reset
  group user
    ./user/: main.c
  group src
    ./SRC/: TARGET.C Startup.s
